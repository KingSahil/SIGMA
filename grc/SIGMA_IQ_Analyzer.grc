options:
  parameters:
    author: SIGMA Team
    category: '[SIGMA] Signal Analysis'
    description: Basic IQ signal analysis flowgraph for SIGMA
    generate_options: qt_gui
    id: sigma_iq_analyzer
    output_language: python
    title: SIGMA IQ Analyzer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate of the IQ recording in samples/sec
    value: '1000000'
  states: {}
- name: constellation_sink
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Constellation view; useful for PSK/QAM inspection
    grid: 'True'
    label1: IQ Samples
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: FFT-based frequency spectrum
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: IQ Spectrum
    name: IQ Frequency Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: iq_file
  id: blocks_file_source
  parameters:
    comment: Complex float32 IQ file. Change this path to your .iq file.
    file: signal.iq
    repeat: 'False'
    type: complex
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Time-domain view of the IQ signal
    grid: 'True'
    label1: I/Q
    label2: ''
    name: IQ Time Domain
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [iq_file, '0', constellation_sink, '0']
- [iq_file, '0', freq_sink, '0']
- [iq_file, '0', time_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
